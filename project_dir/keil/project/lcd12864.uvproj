# Keil uVision project lcd12864.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: lcd12864 +hex
  c flags: Optimize=8 SizeSpeed=1
  group startup
    ./: STARTUP.A51
  group drivers
    ../../drivers/lcd12864/: lcd12864.c
  group user
    ../../user/: main.c
